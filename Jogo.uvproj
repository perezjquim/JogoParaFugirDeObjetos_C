# Keil uVision project Jogo.uvproj, settings and files
target Projeto (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: testeX +hex
  c flags: Optimize=8 SizeSpeed=1
  group AT89S51 (Controlador)
    ./: Jogo.c
